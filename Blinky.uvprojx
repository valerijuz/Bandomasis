# Keil uVision project Blinky.uvprojx, settings and files
target STM32L152 Flash (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: STM32L1XX_MD
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Files
    ./: LED.c Blinky.c
  group Documentation
    ./: Abstract.txt
  group ::Device
    RTE/Device/STM32L152RB/: startup_stm32l1xx_md.s system_stm32l1xx.c
target STM32L152 RAM (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: STM32L1XX_MD VECT_TAB_SRAM
  memory RVCT4: ROM 0x20000000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x2000
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
